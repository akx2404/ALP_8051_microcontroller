ORG 0000H
LJMP MAIN
ORG 000BH
CPL P3.2
CLR TF0
RETI

ORG 0023H
JB TI,TRANS
MOV A,SBUF
MOV P0,A
CLR RI
RETI
TRANS: RETI


ORG 0050H
MAIN: MOV TMOD,#00100010B
MOV TH0,#0A4H
MOV TH1,#-6
MOV SCON,#01010000B
MOV IE,#10010010B
MOV IP,#00000010B
SETB TR1
SETB TR0
MOV P1,#0FFH
CLR TI
BACK: MOV A,P1
MOV SBUF,A
HERE: JNB TI,HERE
MOV P2,A
CLR TI
SJMP BACK
END