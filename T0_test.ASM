ORG 000h
MOV DPTR, #500H
MOV R0, #60H  ;MEMORY FOR EVEN
MOV R1, #50H  ;MEMORY FOR ODD
MOV R5, #6    ;COUNTER FOR TOTAL DATA
MOV R4, #8    ;COUNTER FOR COUNTING 1s IN THE DATA
MOV R7, #0    ;VALUE TO STORE NUMBER OF 1s
MOV B, #2H
LOOP: CLR A
MOV R2, #0H
MOVC A, @A+DPTR
MOV R2, A

CHECK: RRC A
JNC NEXT
INC R7

NEXT: DJNZ R4, CHECK
CLR A
MOV A, R7
DIV AB
MOV R6, B
CJNE R6, #0H, ODD
SJMP EVE

ODD: MOV @R1, R2
DJNZ R5, LOOP

EVE: MOVE @R0, R2
DJNZ R5, LOOP


HERE: SJMP HERE
ORG 500H
DB 58H, 3EH, 7FH, 4EH, 38H, 9FH
END
